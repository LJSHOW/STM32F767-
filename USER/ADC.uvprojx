# Keil uVision project ADC.uvprojx, settings and files
target ADC (ARM-ADS)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\ADC;..\USMART;..\HARDWARE\DMA;..\HARDWARE\CO;..\HARDWARE\CO2;..\HARDWARE\DHT11;..\HARDWARE\IIC;..\HARDWARE\PCF8574;..\HARDWARE\PM2.5;..\HARDWARE\KEY;..\HARDWARE\USART3;..\HARDWARE\TIMER;..\Gizwits;..\Utils;..\HARDWARE\FAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/CO/: co.c
    ../HARDWARE/CO2/: co2.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/PM2.5/: pm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/FAN/: fan.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
